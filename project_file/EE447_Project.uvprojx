# Keil uVision project EE447_Project.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: EE447_Project
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: MY_ST_ISR.s Startup.s Program_Directives.s SYSTICK_INIT.s ADC_INIT.s FFT_MAGNITUDE.s CONVRT.s OutChar.s OutStr.s LED_PINS_INIT.s TIMERS_INIT.s STEP_MOTOR_ISR.s LED_POWER_ISR.s STEP_OUT_PINS_INIT.s FULL_STEP.s PROJECT_PARAMS.s ONBOARDSW_INIT.s ONBOARD_SWITCH_ISR.s ADJUST_STEP_FREQUENCY_LED_PWM.s SPI_INIT.s SCREEN_INIT.s DELAY.s UPDATE_SCREEN.s SCREEN_SEND_CHAR.s SCREEN_SEND_COMMAND.s SCREEN_FIND_WHICH_NUMBER.s UPDATE_SCREEN_EXTENDED.s KEYBOARD_PINS_INIT.s DEBOUNCE_A.s DEBOUNCE_C.s KEYBOARD_TAKE_INPUT_ISR.s POLL_KEYBOARD.s KEYBOARD_STATE.s MAGNITUDE_ADC_INIT.s MAGNITUDE_SET_T.s RELEASE_KEYBOARD.s
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev

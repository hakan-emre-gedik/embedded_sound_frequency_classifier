	;LABEL		DIRECTIVE	VALUE		COMMENT
				AREA        PROJECT_PARAMS, DATA, READWRITE 
				THUMB
WHICH_LED		DCD			2 
DOMINANT_FREQUENCY 	FILL 		15
DOMINANT_MAGNITUDE 	FILL		15
HIGH 			DCD 		10000
LOW 			DCD 		10000
STEP_DIR		DCD			0 
LOW_FREQ_T		DCD			0
HIGH_FREQ_T		DCD 		0 
LOW_FREQ_DIGITS	DCD			0
HIGH_FREQ_DIGITS DCD 		0 
AMPLITUDE_T		DCD			0
AMPLITUDE_DIGITS DCD			0
TRESHOLD_SETTING_MODE DCD	0 
SETTING_MODE	DCD			0
KEYBOARD_IN_OUT DCD			0 
;LABEL		DIRECTIVE	VALUE		COMMENT
			AREA    	PROJECT_PARAMS_INIT, READONLY, CODE
			THUMB
			EXTERN		CONVRT 
			EXPORT  	PROJECT_PARAMS_INIT ; Make available
			EXPORT 		WHICH_LED 
			EXPORT		DOMINANT_FREQUENCY 
			EXPORT		DOMINANT_MAGNITUDE
			EXPORT 		HIGH 
			EXPORT 		LOW 
			EXPORT 		STEP_DIR 
			EXPORT 		LOW_FREQ_T
			EXPORT		HIGH_FREQ_T
			EXPORT 		LOW_FREQ_DIGITS
			EXPORT		HIGH_FREQ_DIGITS
			EXPORT		AMPLITUDE_T 
			EXPORT		AMPLITUDE_DIGITS
			EXPORT		TRESHOLD_SETTING_MODE 
			EXPORT 		SETTING_MODE 
			EXPORT		KEYBOARD_IN_OUT
PROJECT_PARAMS_INIT_ PROC 
			LDR		R1, =WHICH_LED
			MOV		R0, #0x03 
			STR		R0, [R1]
			
			LDR		R1, =HIGH
			MOV		R0, #0x100 
			STR		R0, [R1]
			
			LDR		R1, =LOW
			LDR		R0, =3500 ; CHOSEN HIGH VALUE FOR 500HZ
			STR		R0, [R1]
			
			LDR		R1, =STEP_DIR 
			MOV		R0, #0x00
			STR		R0, [R1]
			
			LDR		R1, =LOW_FREQ_T 
			MOV		R0, #300 ; INITIAL LOW FREQ
			STR		R0, [R1]
			
			LDR		R1, =HIGH_FREQ_T 
			MOV		R0, #700 ; INITIAL HIGH FREQ 
			STR		R0, [R1]
			
			LDR		R1, =AMPLITUDE_T 
			MOV		R0, #100
			STR		R0, [R1]
			
			PUSH {LR}
			MOV		R4, #500 
			LDR		R5, =DOMINANT_FREQUENCY 
			BL CONVRT
			POP {LR}
			
			PUSH {LR}
			MOV		R4, #150
			LDR		R5, =DOMINANT_MAGNITUDE
			BL CONVRT
			POP {LR}
			
			LDR		R1, =TRESHOLD_SETTING_MODE
			MOV		R0, 0x00 
			STR		R0, [R1]
			
			LDR		R1, =SETTING_MODE 
			MOV		R0, #0x00 
			STR		R0, [R1]
			
			LDR		R1, =KEYBOARD_IN_OUT 
			MOV		R0, #0x00
			STR		R0, [R1]
			
			BX LR 
			ENDP 
			